# Keil uVision project TivaGasSensor.uvprojx, settings and files
target TivaGasSensor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PGE Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TivaGasSensor
  AfterMake: fromelf --bin --output .\rvmdk\TivaGasSensor.bin .\rvmdk\TivaGasSensor.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ../buildpath
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: TivaGasSensor.sct
  link misc: --entry Reset_Handler
  group Source
    ./: main.c startup_rvmdk.S state.h state.c init.h init.c display.h util.h display.c stdtypes.h gassensor.c gassensor.h watchdog.h watchdog.c conversion.h conversion.c button_io.h button_io.c data_logger.c global.c sensortimer.c uart_io.c util.c data_logger.h global.h sensortimer.h types.h uart_io.h
  group Libraries
    driverlib/rvmdk/: driverlib.lib
    grlib/rvmdk/: grlib.lib
    ./drivers/: cfal96x64x16.c buttons.c
    ./utils/: uartstdio.c
software components: CMSIS:CORE 5.1.1
